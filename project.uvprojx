# Keil uVision project project.uvprojx, settings and files
target rtthread-m460 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99 --diag_suppress=66,1296,186
  c include: rt-thread\components\libc\compilers\common\extension;board;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;packages\freemodbus-latest\modbus\ascii;libraries\m460\rtt_port\emac;packages\freemodbus-latest\modbus\rtu;rt-thread\components\net\sal\include\socket\sys_socket;libraries\m460\Device\Nuvoton\m460\Include;rt-thread\libcpu\arm\common;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\netdev\include;rt-thread\components\legacy;rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket;rt-thread\components\libc\posix\ipc;packages\tcpserver-latest;rt-thread\components\net\lwip\lwip-2.1.2\src\include\netif;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\lwip\lwip-2.1.2\src\include;rt-thread\components\libc\posix\io\stdio;libraries\nu_packages\NuUtils\inc;packages\freemodbus-latest\modbus\tcp;packages\freemodbus-latest\modbus\include;rt-thread\components\dfs\include;rt-thread\components\legacy\dfs;rt-thread\components\net\sal\include;applications;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;rt-thread\components\dfs\filesystems\devfs;libraries\nu_packages\TPC;libraries\m460\StdDriver\inc;board\NuPinConfig;packages\freemodbus-latest\port;rt-thread\include;libraries\m460\rtt_port;rt-thread\components\drivers\include;rt-thread\components\net\lwip\port;rt-thread\components\net\sal\impl;.;rt-thread\components\utilities\ulog;libraries\m460\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\linking_scripts\m460_flash.sct
  group Applications
    applications/: mnt.c main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    libraries/m460/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    libraries/m460/Device/Nuvoton/m460/Source/: system_m460.c
    libraries/m460/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_canfd.c drv_ccap.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
    libraries/m460/rtt_port/emac/: drv_emac.c mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group FreeModbus
    packages/freemodbus-latest/samples/: sample_mb_slave.c
    packages/freemodbus-latest/port/: porttcp.c port.c porttimer.c portevent.c portserial.c user_mb_app.c
    packages/freemodbus-latest/modbus/: mb.c
    packages/freemodbus-latest/modbus/functions/: mbfuncinput.c mbfuncother.c mbfuncholding.c mbutils.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c
    packages/freemodbus-latest/modbus/ascii/: mbascii.c
    packages/freemodbus-latest/modbus/rtu/: mbcrc.c mbrtu.c
    packages/freemodbus-latest/modbus/tcp/: mbtcp.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    libraries/m460/StdDriver/src/: nu_acmp.c nu_scuart.c nu_spi.c nu_usci_spi.c nu_usbd.c nu_ecap.c nu_eqei.c nu_qspi.c nu_dac.c nu_crc.c nu_fmc.c nu_ccap.c nu_usci_uart.c nu_sdh.c nu_usci_i2c.c nu_timer.c nu_canfd.c nu_hsusbd.c nu_epwm.c nu_kpi.c nu_sc.c nu_wdt.c nu_trng.c nu_eadc.c nu_hbi.c nu_pdma.c nu_i2s.c nu_bmc.c nu_timer_pwm.c nu_rtc.c nu_keystore.c nu_spim.c nu_ebi.c nu_crypto.c nu_sys.c nu_bpwm.c nu_wwdt.c nu_i2c.c nu_clk.c nu_gpio.c nu_rng.c nu_uart.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group tcpserver
    packages/tcpserver-latest/: tcpserver.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
software components: CMSIS:CORE 5.4.0
