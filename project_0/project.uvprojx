# Keil uVision project project.uvprojx, settings and files
target rtthread-m460 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RT_USING_LIBC, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99 --diag_suppress=66,1296,186
  c include: applications;.;libraries\m460\CMSIS\Include;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;board;board\NuPinConfig;libraries\m460\Device\Nuvoton\m460\Include;libraries\m460\rtt_port;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;.;rt-thread\include;libraries\m460\StdDriver\inc;packages\LVGL-latest\src;packages\LVGL-latest\src\core;packages\LVGL-latest\src\draw;packages\LVGL-latest\src\extra;packages\LVGL-latest\src\font;packages\LVGL-latest\src\hal;packages\LVGL-latest\src\misc;packages\LVGL-latest\src\widgets;packages\LVGL-latest\src\draw\arm2d;packages\LVGL-latest\src\draw\nxp;packages\LVGL-latest\src\draw\sdl;packages\LVGL-latest\src\draw\stm32_dma2d;packages\LVGL-latest\src\draw\sw;packages\LVGL-latest\src\draw\swm341_dma2d;packages\LVGL-latest\src\draw\nxp\pxp;packages\LVGL-latest\src\draw\nxp\vglite;packages\LVGL-latest\src\extra\layouts;packages\LVGL-latest\src\extra\libs;packages\LVGL-latest\src\extra\others;packages\LVGL-latest\src\extra\themes;packages\LVGL-latest\src\extra\widgets;packages\LVGL-latest\src\extra\layouts\flex;packages\LVGL-latest\src\extra\layouts\grid;packages\LVGL-latest\src\extra\libs\bmp;packages\LVGL-latest\src\extra\libs\ffmpeg;packages\LVGL-latest\src\extra\libs\freetype;packages\LVGL-latest\src\extra\libs\fsdrv;packages\LVGL-latest\src\extra\libs\gif;packages\LVGL-latest\src\extra\libs\png;packages\LVGL-latest\src\extra\libs\qrcode;packages\LVGL-latest\src\extra\libs\rlottie;packages\LVGL-latest\src\extra\libs\sjpg;packages\LVGL-latest\src\extra\others\fragment;packages\LVGL-latest\src\extra\others\gridnav;packages\LVGL-latest\src\extra\others\imgfont;packages\LVGL-latest\src\extra\others\monkey;packages\LVGL-latest\src\extra\others\msg;packages\LVGL-latest\src\extra\others\snapshot;packages\LVGL-latest\src\extra\themes\basic;packages\LVGL-latest\src\extra\themes\default;packages\LVGL-latest\src\extra\themes\mono;packages\LVGL-latest\src\extra\widgets\animimg;packages\LVGL-latest\src\extra\widgets\calendar;packages\LVGL-latest\src\extra\widgets\chart;packages\LVGL-latest\src\extra\widgets\colorwheel;packages\LVGL-latest\src\extra\widgets\imgbtn;packages\LVGL-latest\src\extra\widgets\keyboard;packages\LVGL-latest\src\extra\widgets\led;packages\LVGL-latest\src\extra\widgets\list;packages\LVGL-latest\src\extra\widgets\menu;packages\LVGL-latest\src\extra\widgets\meter;packages\LVGL-latest\src\extra\widgets\msgbox;packages\LVGL-latest\src\extra\widgets\span;packages\LVGL-latest\src\extra\widgets\spinbox;packages\LVGL-latest\src\extra\widgets\spinner;packages\LVGL-latest\src\extra\widgets\tabview;packages\LVGL-latest\src\extra\widgets\tileview;packages\LVGL-latest\src\extra\widgets\win;applications\lvgl;packages\LVGL-latest\env_support\rt-thread;libraries\nu_packages\FSA506;libraries\nu_packages\TPC;libraries\nu_packages\NuUtils\inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\utilities\utest
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\linking_scripts\m460_flash.sct
  group Applications
    applications/: mnt.c main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    libraries/m460/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    libraries/m460/Device/Nuvoton/m460/Source/: system_m460.c
    libraries/m460/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_canfd.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    libraries/m460/StdDriver/src/: nu_ebi.c nu_ecap.c nu_crypto.c nu_kpi.c nu_trng.c nu_keystore.c nu_eadc.c nu_sys.c nu_spim.c nu_dac.c nu_wdt.c nu_qspi.c nu_ccap.c nu_rtc.c nu_pdma.c nu_i2c.c nu_canfd.c nu_usbd.c nu_rng.c nu_hsusbd.c nu_sdh.c nu_epwm.c nu_fmc.c nu_gpio.c nu_eqei.c nu_spi.c nu_timer_pwm.c nu_usci_i2c.c nu_bmc.c nu_acmp.c nu_timer.c nu_bpwm.c nu_i2s.c nu_hbi.c nu_usci_spi.c nu_wwdt.c nu_sc.c nu_scuart.c nu_crc.c nu_usci_uart.c nu_clk.c nu_uart.c
  group LVGL
    packages/LVGL-latest/src/core/: lv_obj.c lv_obj_style_gen.c lv_obj_pos.c lv_obj_class.c lv_event.c lv_refr.c lv_indev_scroll.c lv_theme.c lv_obj_tree.c lv_obj_scroll.c lv_disp.c lv_group.c lv_obj_draw.c lv_obj_style.c lv_indev.c
    packages/LVGL-latest/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/LVGL-latest/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-latest/src/font/: lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_12_subpx.c lv_font_unscii_8.c lv_font.c lv_font_fmt_txt.c lv_font_montserrat_18.c lv_font_montserrat_28.c lv_font_montserrat_10.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_44.c lv_font_montserrat_24.c lv_font_montserrat_36.c lv_font_montserrat_42.c lv_font_montserrat_38.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_16.c lv_font_montserrat_8.c lv_font_loader.c lv_font_simsun_16_cjk.c lv_font_montserrat_22.c lv_font_montserrat_32.c lv_font_montserrat_26.c lv_font_montserrat_40.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_34.c lv_font_montserrat_20.c lv_font_unscii_16.c
    packages/LVGL-latest/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-latest/src/widgets/: lv_roller.c lv_objx_templ.c lv_table.c lv_textarea.c lv_arc.c lv_checkbox.c lv_switch.c lv_btn.c lv_line.c lv_btnmatrix.c lv_canvas.c lv_dropdown.c lv_img.c lv_label.c lv_slider.c lv_bar.c
    packages/LVGL-latest/src/draw/sdl/: lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_composite.c lv_draw_sdl_mask.c lv_draw_sdl_arc.c lv_draw_sdl_stack_blur.c lv_draw_sdl_polygon.c lv_draw_sdl_bg.c lv_draw_sdl.c lv_draw_sdl_rect.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl_line.c
    packages/LVGL-latest/src/extra/widgets/span/: lv_span.c
    packages/LVGL-latest/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_gpu_nxp_vglite.c lv_draw_vglite_rect.c
    packages/LVGL-latest/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-latest/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_win32.c
    packages/LVGL-latest/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-latest/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-latest/src/misc/: lv_printf.c lv_math.c lv_anim.c lv_style_gen.c lv_color.c lv_log.c lv_area.c lv_mem.c lv_gc.c lv_utils.c lv_bidi.c lv_async.c lv_templ.c lv_ll.c lv_style.c lv_fs.c lv_txt.c lv_txt_ap.c lv_tlsf.c lv_lru.c lv_anim_timeline.c lv_timer.c
    packages/LVGL-latest/src/extra/widgets/led/: lv_led.c
    packages/LVGL-latest/src/draw/sw/: lv_draw_sw_img.c lv_draw_sw_line.c lv_draw_sw_arc.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw_polygon.c lv_draw_sw_blend.c lv_draw_sw.c lv_draw_sw_dither.c lv_draw_sw_letter.c lv_draw_sw_gradient.c
    packages/LVGL-latest/src/draw/: lv_img_buf.c lv_img_cache.c lv_draw_transform.c lv_draw_label.c lv_draw_triangle.c lv_draw.c lv_img_decoder.c lv_draw_arc.c lv_draw_mask.c lv_draw_img.c lv_draw_rect.c lv_draw_line.c
    packages/LVGL-latest/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-latest/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-latest/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-latest/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-latest/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-latest/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-latest/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-latest/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-latest/src/extra/widgets/win/: lv_win.c
    packages/LVGL-latest/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-latest/src/extra/others/msg/: lv_msg.c
    packages/LVGL-latest/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-latest/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-latest/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-latest/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-latest/src/draw/nxp/pxp/: lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c
    packages/LVGL-latest/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-latest/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-latest/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-latest/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-latest/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-latest/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-latest/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-latest/src/draw/nxp/: lv_gpu_nxp.c
    packages/LVGL-latest/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-latest/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-latest/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-latest/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-latest/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-latest/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-latest/src/extra/: lv_extra.c
    packages/LVGL-latest/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-latest/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-latest/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-latest/src/extra/widgets/list/: lv_list.c
  group LVGL-demo
    packages/lv_music_demo-latest/assets/: img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_wave_top.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_btn_next.c
    packages/lv_music_demo-latest/: lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c lv_demo_rtt_music.c
  group LVGL-port
    applications/lvgl/: lv_demo.c lv_port_disp.c lv_port_indev.c
    packages/LVGL-latest/env_support/rt-thread/: lv_rt_thread_port.c
  group nu_pkgs_fsa506
    libraries/nu_packages/FSA506/: lcd_fsa506.c fsa506_ebi.c
  group nu_pkgs_tpc
    libraries/nu_packages/TPC/: tpc_worker.c st1663i.c
  group UTest
    rt-thread/components/utilities/utest/: utest.c
software components: CMSIS:CORE 5.4.0
